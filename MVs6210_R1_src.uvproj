# Keil uVision project MVs6210_R1_src.uvproj, settings and files
target MVs6210_R1_src (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ..\MVs6210 +hex
  c flags: Optimize=9
  c include: .\config;.\device;.\display;.\fs;.\key;.\lib_if;.\play;.\system;.\library;.\power;.\radio;.\eeprom;.\spi_flash;.\slave;.\bluetooth;.\i2c
  link misc: NOOVERLAY
  group config
    ./config/: syscfg.h
  group lib_if
    ./lib_if/: clk_if.c user_interface.c
  group library
    ./library/: AU6210R1.OBJ MVs6210_R1_01_P9_reader.LIB
  group device
    ./device/: card_reader_ctrl.c devctrl.c device.c usb_audio_ctrl.c linein_ctrl.c rtc_ctrl.c touchkey_ctrl.c
  group fs
    ./fs/: presearch.c otp_fs.c
  group play
    ./play/: playctrl.c otp_play.c file_dec_asm.A51
  group system
    ./system/: sysctrl.c STARTUP.a51 interrupt.c message.c sys_on_off.c debug.c breakpoint.c pt231x.c
    ./power/: power_monitor.c
  group key
    ./key/: key.c ir_key.c adc_key.c power_key.c gpio_key.c coding_key.c touch_key.c
  group eeprom
    ./eeprom/: 24cxx.c i2c.c
  group display
    ./display/: display.c seg_lcd_disp.c seg_led_disp.c seg_panel.c sled_disp.c
  group radio
    ./radio/: radio_app_interface.c radio_ctrl.c mv_fm.c
  group spi_flash
    ./spi_flash/: spi_flash.c spi_fs.c spi_flash_asm.a51 spi_play.c
  group document
    ./: release note.txt
  group bluetooth
    ./bluetooth/: bluetooth_ctrl.c bt.c bluetooth_cmd.c
  group slave
    ./slave/: slave_cmd.c slave_ctrl.c
  group i2c
    ./i2c/: npca110x.c
